# Keil uVision project CM_project.uvprojx, settings and files
target 物联网通讯扩展模块 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Communication_Module +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\HILINK;..\HARDWARE\DMA;..\HARDWARE\TIMER;..\HARDWARE\STMFLASH;..\HARDWARE\LCD(1.44inches);..\HARDWARE\USMART;..\HARDWARE\LCD(1.44inches)
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c global.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/USMART/: usart1.c
    ../HARDWARE/LCD(1.44inches)/: GUI_144.c LCD_144.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart4_ZIG1.c usart_cfg.c usart3_zigbee.c usart2_android.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_crc.c stm32f10x_bkp.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_flash.c
software components: CMSIS:CORE 5.1.1
