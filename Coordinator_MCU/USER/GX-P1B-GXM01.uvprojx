# Keil uVision project GX-P1B-GXM01.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GX-P1B-GXM01 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,CR95HF
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\HILINK;..\HARDWARE\DMA;..\HARDWARE\TIMER;..\HARDWARE\FLASH_25Q64;..\HARDWARE\ds1302;..\HARDWARE\CR95HF\inc;..\HARDWARE\CR95HF\src;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c global.h
  group APP
    ../SYSTEM/usart/: usart_cfg.c usart_cfg.h usart4_ZIG1.c usart4_ZIG1.h usart2_rs485.c usart2_rs485.h usart3_android.c usart3_android.h
    ./: CR95HF.c CR95HF.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ds1302/: DS1302.c DS1302.h
    ../HARDWARE/FLASH_25Q64/: flash_25q64.c flash_25q64.h
    ../HARDWARE/STMFLASH/: stmflash.c stmflash.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_crc.c stm32f10x_bkp.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_flash.c
  group CR95HF_PCB_LIB
    ../HARDWARE/CR95HF/src/: lib_iso7816pcd.c lib_iso14443Apcd.c lib_iso14443Bpcd.c lib_iso15693pcd.c lib_iso18092pcd.c lib_PCD.c
    ../HARDWARE/CR95HF/inc/: lib_95HF.h lib_ConfigManager.h lib_iso7816pcd.h lib_iso14443A.h lib_iso14443Apcd.h lib_iso14443Bpcd.h lib_iso15693pcd.h lib_iso18092pcd.h lib_nfctype1pcd.h lib_nfctype2pcd.h lib_nfctype3pcd.h lib_nfctype4pcd.h lib_nfctype5pcd.h lib_PCD.h miscellaneous.h
  group CR95HF_Driver
    ./: hw_config.c hw_config.h common.h common.c
    ../HARDWARE/CR95HF/inc/: drv_95HF.h drv_spi.h drv_uart.h drv_interrupt.h
    ../HARDWARE/CR95HF/src/: drv_95HF.c drv_spi.c drv_uart.c drv_interrupt.c
  group CR95HF_Manager_Libraries
    ../HARDWARE/CR95HF/src/: lib_ConfigManager.c
software components: CMSIS:CORE 4.3.0
