# Keil uVision project GS-P1B-GXO01.uvprojx, settings and files
target 物联网基础实验电路板 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GS-P1B-GXO01 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\HILINK;..\HARDWARE\DMA;..\HARDWARE\TIMER;..\HARDWARE\FLASH_25Q64;..\HARDWARE\ds1302;..\HARDWARE\CR95HF\inc;..\HARDWARE\CR95HF\src;..\SYSTEM\bitband;..\SYSTEM\iic;..\SYSTEM\adc;..\HARDWARE\HC_SR04;..\HARDWARE\PERIPHERAL;..\HARDWARE\SHT1X;..\HARDWARE\LCD(1.44inches);..\HARDWARE\TempMS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c my_define.c global.h
    ../SYSTEM/bitband/: bit_band.h
  group APP
    ../SYSTEM/usart/: usart_cfg.c usart1_RS485_V&I.c usart3_zigbee.c usart2_android.c
    ../SYSTEM/iic/: driver_iic.c
    ../SYSTEM/adc/: adc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/FLASH_25Q64/: flash_25q64.c
    ../HARDWARE/PERIPHERAL/: peripheral.c
    ../HARDWARE/SHT1X/: SHT1X.c
    ../HARDWARE/LCD(1.44inches)/: GUI_144.c LCD_144.c
    ../HARDWARE/TempMS/: tempMS.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_crc.c stm32f10x_bkp.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
