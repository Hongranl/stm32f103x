<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sensor_tem_hum_light.ewp</path>
    </project>
    <batchBuild />
</workspace>
