# IAR project sensor_tem_hum_light.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; ; Temp_MS
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sensor_tem_hum_light.hex
  ILINK.IlinkOutputFile: sensor_86box.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: ALL_Includes.h LED_CON.c LED_CON.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h uart.c uart.h
    Temp_MS/: lightMS.c tempMS.c
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_uart1.c
