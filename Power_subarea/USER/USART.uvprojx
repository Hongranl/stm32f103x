# Keil uVision project USART.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\HILINK;..\HARDWARE\DMA;..\HARDWARE\TIMER;..\HARDWARE\FLASH_25Q64;..\HARDWARE\ds1302;..\HARDWARE\CR95HF\inc;..\HARDWARE\CR95HF\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c global.h
  group APP
    ../SYSTEM/usart/: usart_cfg.c usart_cfg.h usart3_RS485_V&I.c usart3_RS485_V&I.h usart1_zigbee_comm.c usart1_zigbee_comm.h
    ./: fuc_595.c fuc_595.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ds1302/: DS1302.c DS1302.h
    ../HARDWARE/FLASH_25Q64/: flash_25q64.c flash_25q64.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_crc.c stm32f10x_bkp.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c
software components: CMSIS:CORE 4.3.0
