# Keil uVision project CCBD_Student.uvprojx, settings and files
target 智慧实训室-实训管理器 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SH95_Temp +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Member_Detect\ST_95HF\95HF_Lib\inc;.\Member_Detect\ST_95HF\95HF_Lib\src;.\Member_Detect\ST_95HF\95HF_Config\inc;.\Member_Detect\ST_95HF\95HF_Config\src;.\Member_Detect\ST_95HF\95HF_prtApp\inc;.\Member_Detect\ST_95HF\95HF_prtApp\src;.\Usr;.\Usr\reWrite;.\Usr
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group 用户文件
    ./Usr/: main.c delay.c
    ./Member_Detect/ST_95HF/95HF_Config/src/: stm32f10x_it.c
  group ST95_HF总成
    ./Member_Detect/ST_95HF/95HF_Config/src/: prtApp_SH95.c hw_config.c common.c
    ./Member_Detect/ST_95HF/95HF_Lib/src/: drv_95HF.c drv_interrupt.c drv_spi.c drv_uart.c lib_ConfigManager.c lib_iso7816pcd.c lib_iso14443Apcd.c lib_iso14443Bpcd.c lib_iso15693pcd.c lib_iso18092pcd.c lib_PCD.c
    ./Member_Detect/ST_95HF/95HF_prtApp/src/: drv_LED.c
  group 系统驱动改写
    ./Usr/reWrite/: USART_STM32F10x.c
  group 备忘录
    ./Usr/: 备忘录.txt
  group 通讯构件
    ./Usr/: RSART_MCU.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:CAN 1.6, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
