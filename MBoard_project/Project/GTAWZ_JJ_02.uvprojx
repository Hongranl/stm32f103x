# Keil uVision project GTAWZ_JJ_02.uvprojx, settings and files
target 山西商务物联网实训台 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GTAWZ_JJ_02 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\Module;..\User\reWrite;..\User\FlashOP;..\Module\LCD(1.44inches);..\Module\KEY&TIPS;..\Module\Debug_USART;..\Module\Transmitter_USART;..\Module\Entrance_guard;..\Module\Fire_MS;..\Module\Gas_MS;..\Module\Light_MS;..\Module\Pyro_MS;..\Module\Simu_MS;..\Module\Smoke_MS;..\Module\Temp_MS;..\Module\AnalogMS;..\Module\Infra_Trans;..\Module\Pwm_CM;..\Module\Relays_CM;..\Module\Source_CM;..\Module\Curtain_CM;..\Module\Speak_CM;..\备忘录;..\Module\Relays_light_CM;..\Module\Shake_MS;..\Module\Relays_outlet_CM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group 用户文件
    ../User/: Main.c Bsp.c stm32f10x_it.c delay.c intrrupt.c
    ../Module/: Tips.c Moudle_DEC.c
    ../User/FlashOP/: stmflash.c
  group 门禁
    ../Module/Entrance_guard/: Eguard.c fingerID.c rfID.c kBoard.c rc522_config.c doorLock.c
  group 传感器构件
    ../Module/Fire_MS/: fireMS.c
    ../Module/Pyro_MS/: pyroMS.c
    ../Module/Gas_MS/: gasMS.c
    ../Module/Smoke_MS/: smokeMS.c
    ../Module/Light_MS/: lightMS.c
    ../Module/Temp_MS/: tempMS.c
    ../Module/AnalogMS/: analogMS.c
    ../Module/Shake_MS/: shakeMS.c
  group 显示构件
    ../Module/LCD(1.44inches)/: LCD_1.44.c GUI_1.44.c
  group 执行器构件
    ../Module/KEY&TIPS/: Key&Tips.c
    ../Module/Infra_Trans/: infraTrans.c
    ../Module/Pwm_CM/: pwmCM.c
    ../Module/Curtain_CM/: curtainCM.c
    ../Module/Source_CM/: sourceCM.c
    ../Module/Speak_CM/: speakCM.c
    ../Module/Relays_CM/: RelaysCM.c
    ../Module/Relays_light_CM/: RelayslightCM.c
    ../Module/Relays_outlet_CM/: RelaysoutletCM.c
  group 通讯构件
    ../Module/Transmitter_USART/: dataTrans_USART.c
    ../Module/Debug_USART/: debugUart.c
  group 系统驱动文件改写
    ../User/reWrite/: USART_STM32F10x.c
  group 备忘录
    ../备忘录/: 备忘录.txt
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:CAN 1.6, CMSIS Driver:I2C 2.1, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
