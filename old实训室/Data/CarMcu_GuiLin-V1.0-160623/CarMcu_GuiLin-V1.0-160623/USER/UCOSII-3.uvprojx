# Keil uVision project UCOSII-3.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-3 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\MotorDriver;..\HARDWARE\Follow;..\MALLOC;..\HARDWARE\SPI;..\HARDWARE\Voice
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ./: system_stm32f10x.c adc.c cx.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MotorDriver/: MotorDriver.c
    ../HARDWARE/Follow/: Follow.c CarRoad.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/Voice/: Voice.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c usart2.c usart3.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_exti.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
