# Keil uVision project SourceBD.uvprojx, settings and files
target 智慧实训室_电源管理器 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SourceBD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\User\reWrite;.\Member_Detect;.\Member_Operater;.\Member_Transfer;.\Actuator_components
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group 用户文件
    ./User/: UserMain.c delay.c System_init.c
  group 通讯构件
    ./Member_Transfer/: USART_485_VAW_data.c USART_485_APP_data.c USART_Communication.c
  group 执行器构件
    ./Actuator_components/: Relay_CM.c
software components: CMSIS:CORE 4.3.0, CMSIS Driver:USART 2.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
