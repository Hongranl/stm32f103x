# Keil uVision project faultSet.uvproj, settings and files
target 智慧实训室_16路弱电设故板 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: faultSet
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\faultSet;.\User;.\Hardware;.\StdPeriph_Driver
  link misc: REMOVEUNUSED
  group 用户文件
    ./User/: UserMain.c Bsp.c Debug.c
  group 通讯构件
    ./Hardware/: 485Trans_USART.c
  group 驱动构件
    ./Hardware/: SPI_faultSet.c Beep.c
  group 外设库
    ./StdPeriph_Driver/: delay.c EEPROM.c Exti.c GPIO.c Soft_UART.c timer.c USART.C
  group 备忘录
    ./User/: 备忘录.txt
